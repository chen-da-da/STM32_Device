# Keil uVision project Main Control.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MainControl +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\Libraries\CMSIS;.\User\inc;.\User\MALLOC;.\User\SD;.\User\LCD;.\User\FF13B\source;.\User\PRINTF;.\User\WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Starup
    ./Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ./User/src/: main.c stm32f10x_it.c fft_test.c hw_config.c ftcomm.c wificomm.c key.c
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_dma.c
  group Doc
    ./DOC/: readme.txt
  group MALLOC
    ./User/MALLOC/: malloc.c
  group LCD
    ./User/LCD/: LCD.c
  group FF13B
    ./User/FF13B/source/: diskio.c ff.c ffunicode.c
  group SD
    ./User/SD/: spi_sd.c
  group PRINTF
    ./User/PRINTF/: prt_usart1.c
  group WIFI
    ./User/WIFI/: wifi.c
software components: CMSIS:CORE 5.1.1
